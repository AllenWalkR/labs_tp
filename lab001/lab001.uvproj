# Keil uVision project lab001.uvproj, settings and files
target lab001 (ARM-ADS)
  device: LPC1549 NXP
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lab001
  c flags: Optim=1
  c include: ..\lab001;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/MemMang/: heap_1.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group demo
    ./: main.c
    ../common/: basic_io.c
  group system
    ./: startup_MPS_CM3.s
