# Keil uVision project lab001.uvproj, settings and files
target lab001 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lab001
  c flags: Optim=1
  c include: ..\lab001;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/MemMang/: heap_1.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group demo
    ./: main.c
    ../common/: basic_io.c
  group system
    ./: startup_MPS_CM3.s
